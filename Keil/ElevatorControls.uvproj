# Keil uVision project ElevatorControls.uvproj, settings and files
target ElevatorControls (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ElevatorControls +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Src/: main.c main.h
  group LCD1602
    ./Src/: LCD1602.c LCD1602.h
  group Key
    ./Src/: Key.c Key.h
  group L298N
    ./Src/: L298N.c L298N.h
  group Timer
    ./Src/: Timer.c Timer.h
